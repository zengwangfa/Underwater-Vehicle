# IAR project Demo.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S103
  ICCSTM8.CCIncludePath2: App; Bsp; Libraries\STM8S_StdPeriph_Driver\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: Demo.hex
  ILINK.IlinkOutputFile: Demo.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group App
    App/: eeprom.c main.c motor.c stm8s_it.c
  group Bsp
    Bsp/: bsp.c bsp_flash.c bsp_i2c.c bsp_timer.c bsp_uart.c key.c
  group Doc
    Doc/: ReadMe.txt
  group STM8S_StdPeriph_Driver
    Libraries/STM8S_StdPeriph_Driver/src/: stm8s_clk.c stm8s_flash.c stm8s_gpio.c stm8s_tim4.c stm8s_uart1.c
